# Keil uVision project demo_ov2640_tim_dma.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo_ov2640_tim_dma +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Src\Core;.\Src\System;.\Src\Peripheral;.\Src\Module;.\Src\CMSIS\Core;.\Src\CMSIS\Device;.\Src\SPL\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./Src/Core/: main.c stm32f10x_it.c
  group System
    ./Src/System/: systick.c
  group Module
    ./Src/Module/: oled.c ov2640.c ov2640_cfg.c esp8266.c esp8266.h OLED_Data.c MFRC522.c button.c sg90.c beep.c
  group Peripheral
    ./Src/Peripheral/: sccb.c uart.c swi2c.c
  group CMSIS/Core
    ./Src/CMSIS/Core/: core_cm3.c
  group CMSIS/Device
    ./Src/CMSIS/Device/: stm32f10x.h system_stm32f10x.c startup_stm32f10x_md.s
  group SPL
    ./Src/SPL/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
